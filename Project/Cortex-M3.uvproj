# Keil uVision project Cortex-M3.uvproj, settings and files
target Cortex-M3 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Cortex-M3 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\Config;..\GUI;..\GUIDemo;..\ucos_ii\GUI_X;..\ucos_ii\Ports;..\ucos_ii\Source;..\User;..\Libraries\FWlib\src;..\Libraries\FWlib\inc;..\Hardware\24L01;..\Hardware\CTL;..\Hardware\delay;..\Libraries\CMSIS\Startup;..\Hardware\KEY;..\Hardware\lcd;..\Hardware\led;..\Hardware\PWM;..\Hardware\SPI;..\Hardware\usart;..\Libraries\CMSIS;..\Hardware\TIM;..\Hardware\UltrasonicWave;..\Hardware\MPU6050;..\Hardware\bsp_I2C;..\Hardware\kalman
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.h stm32f10x_it.c
  group HARDWARE
    ../Hardware/24L01/: 24l01.c
    ../Hardware/CTL/: control.c
    ../Hardware/delay/: delay.c
    ../Hardware/KEY/: key.c
    ../Hardware/lcd/: glcd.c
    ../Hardware/PWM/: pwm.c
    ../Hardware/SPI/: spi.c
    ../Hardware/usart/: usart.c
    ../Hardware/led/: led.c
    ../Hardware/UltrasonicWave/: UltrasonicWave.c
    ../Hardware/TIM/: TIM6.c
    ../Hardware/bsp_I2C/: bsp_I2C.c kalman.c
    ../Hardware/MPU6050/: mpu6050.c
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_i2c.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Startup
    ../Libraries/CMSIS/Startup/: startup_stm32f10x_hd.s
  group GUI
    ../GUI/: LCD_X_8080_16.c GUIv5_7m_tl___trial.lib
  group GUIDemo
    ../GUIDemo/: GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c
  group Config
    ../Config/: GUIConf.c LCDConf.c
  group ucOS/Ports
    ../ucos_ii/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group ucOS/GUI_X
    ../ucos_ii/GUI_X/: GUI_X_Touch.c GUI_X_uCOS.c
  group ucOS/Source
    ../ucos_ii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group BSP
    ../BSP/: bsp.c
